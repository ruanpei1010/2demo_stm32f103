# Keil uVision project STM32_FOC_PMSM.uvproj, settings and files
target BOOT_FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HALL_3SHUNT +hex
  c flags: OneElfS=1 wLevel=1
  c define: VECT_TAB_FLASH
  c include: ..\inc;..\;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RVMDK
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md_vl.s
  group Source
    ../: stm32f10x_it.c
    ../src/: main.c MC_Clarke_Park.c MC_FOC_Drive.c MC_MotorControl_Layer.c MC_Globals.c MC_PID_regulators.c MC_State_Observer_Interface.c MC_Keys.c MC_Display.c stm32f10x_encoder.c stm32f10x_hall.c stm32f10x_Timebase.c stm32f10x_MCdac.c stm32f10x_svpwm_3shunt.c stm32f10x_svpwm_ics.c stm32f10x_svpwm_1shunt.c stm3210e_lcd.c ili932x.c spi_flash.c stm3210b_lcd.c
  group Parameters .h files
    ../inc/: STM32F10x_MCconf.h MC_Control_Param.h MC_encoder_param.h MC_hall_prm.h MC_PMSM_motor_param.h MC_State_Observer_param.h MC_pwm_1shunt_prm.h MC_pwm_3shunt_prm.h MC_pwm_ics_prm.h
  group Std_lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Lib
    ./lib/: MC_FOC_Methods_lib.lib MC_State_Observer_lib.lib Stm32_Std_Drv.lib
  group Doc
    ./: readme.txt
